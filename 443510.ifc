Properties of the parts of a building model (IFC2X3)

# File
Description: ViewDefinition [CoordinationView_V2.0]
File name: 0001
Time: 2021-08-31T16:36:13
Written by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013
Made in: 20170223_1515(x64) - Exporter 18.4.0.0 - Alternate UI 18.4.0.0
Comment: STEP Physical File produced by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013 * Module: EDMstepFileFactory/EDMstandAlone * Creation date: Tue Aug 31 16:36:13 2021 * Host: DESKTOP-4UM54TC * Database: C:\Users\Vlad\AppData\Local\Temp\{71FCC647-FFDD-47FA-B73B-0558F4D674E7}\ifc * Database version: 5507 * Database creation date: Tue Aug 31 16:36:13 2021 * Schema: IFC2X3 * Model: DataRepository.ifc * Model creation date: Tue Aug 31 16:36:13 2021 * Header model: DataRepository.ifc_HeaderModel * Header model creation date: Tue Aug 31 16:36:13 2021 * EDMuser: sdai-user * EDMgroup: sdai-group * License ID and type: 5605 : Permanent license. Expiry date: * EDMstepFileFactory options: 020000

# IfcProject, 0001
LongName: Project Name; Phase: Project Status

# IfcSite, Default
RefLatitude: 42, 21, 31, 181945; RefLongitude: -71, -3, -24, -263305; RefElevation: 0 mm
Other - Category: Project Information; Client Name: Owner; Project Address: Enter address here; Project Issue Date: Issue Date; Project Name: Project Name; Project Number: 0001; Project Status: Project Status

# IfcBuilding
Other - Category: Project Information; Client Name: Owner; Project Address: Enter address here; Project Issue Date: Issue Date; Project Name: Project Name; Project Number: 0001; Project Status: Project Status

# IfcBuildingStorey: Level:8mm Head, Level 1
LongName: Level 1; Elevation: 0 mm
Other(Type) - Category: Levels; Family Name: Level
Identity Data(Type) - Type Name: 8mm Head
Graphics(Type) - Color: 0; Line Pattern: Centre; Line Weight: 1; Symbol: M_Level Head - Circle: M_Level Head - Circle; Symbol at End 1 Default: no; Symbol at End 2 Default: yes
Constraints(Type) - Elevation Base: Project Base Point
Constraints - Elevation: 0 mm
Dimensions - Computation Height: 0 mm
Identity Data - Building Story: yes; Name: Level 1; Structural: no
Other - Category: Levels; Family: Level: 8mm Head; Family and Type: Level: 8mm Head; Type: Level: 8mm Head; Type Id: Level: 8mm Head

# IfcDistributionPort (2)
Description: Flow; FlowDirection: SOURCEANDSINK

# IfcFlowController: 443510 Shut-off connector, DN10, L=50, 443510(2021):443510 Shut-off connector, DN10, L=50:331238
In: Level 1
Type - PredefinedType: FAUCET; Material: Brass
Type - Dimensions - NominalDepth: 23.9678 mm; NominalHeight: 41.299 mm; NominalWidth: 101.284 mm
Type - General - Author: BIMstone; BIMObjectName: 443510(2021); ManufacturerName: Oras; ManufacturerURL: http://www.oras.com; NBSDescription: Water supply fittings for baths; NBSReference: 45-35-70/315; ProductInformation: n/a; Revision: n/a; Uniclass2: TE_60_60_40_78; Uniclass2015Description: Shut-off pipe sections; Uniclass2015Reference: TE_60_60_40_78; Version: 1; VersionDate: 03/08/2021
Type - Green Building Properties - Customs Code: 84818039; EAN Number: 6414150098017; EN Standard: EN 215; LVI Number: 4032034
Type - Identity Data - 2D/3D/BIM Files URL: http://static.oras.com/bim/443510; Catalog Drawing URL: http://static.oras.com/catdrw/443510; Dimension Drawing URL: http://static.oras.com/dimdrw/443510; FDV Document URL: http://www.oras.com/datasheet/443510/en/fdv; Group: RadiatorValve; Manufacturer: Oras; Model: 443510 Shut-off connector, DN10, L=50; Name_en: 443510 Shut-off connector, DN10, L=50; OmniClass Number: 23.45.55.00; OmniClass Title: Sanitary Faucets, Wastes; Package Weight: 0.129 kg; Product Code: 443510; Product Datasheet: http://www.oras.com/datasheet/443510/en; Product Family: Oras; Product Image URL: http://static.oras.com/image/443510; Product URL: http://static.oras.com/443510; Technical DataSheet URL: http://www.oras.com/datasheet/443510/en; Type Name: 443510 Shut-off connector, DN10, L=50
Type - Materials and Finishes - FaucetMainMaterial: Brass
Type - Mechanical - Connection: InternalThread; Connection Size: G3/8; DN Size: DN10; Installation and Maintenance: http://static.oras.com/manual/443510; Max. Hot Water Supply: 120 kg/K/s3
Type - Other - Category: Plumbing Fixtures; AccessibilityPerformance: n/a; AssetType: Fixed; Brand: Oras; CodePerformance: n/a; Color: Chrome; Constituents: n/a; DurationUnit: Year; ExpectedLife: n/a; Family Name: 443510(2021); Finish: Polished; Grade: n/a; Material: Brass; ModelNumber: n/a; ModelReference: 443510; Name: 443510 Shut-off connector, DN10, L=50; ReplacementCost: n/a; Shape: Sculptured; Size: 280x190x100 mm; SustainabilityPerformance: n/a; WarrantyDescription: http://warranty.oras.com; WarrantyDurationLabor: n/a; WarrantyDurationParts: n/a; WarrantyDurationUnit: Year; WarrantyGuarantorLabor: n/a; WarrantyGuarantorParts: n/a
Constraints - DefaultElevation: 900 mm; Host: Level : Level 1; Level: Level: Level 1; Offset: 0 mm
Dimensions - Area: 0.00425343 m2; InletConnectionSize: 20 mm; InletDistance: 150 mm; InletRadius: 10 mm; Volume: 0.0000494961 m3
Identity Data - Mark: 22
Mechanical - System Classification: Hydronic Supply
Other - AssetIdentifier: n/a; Barcode: n/a; Family: 443510(2021): 443510 Shut-off connector, DN10, L=50; Family and Type: 443510(2021): 443510 Shut-off connector, DN10, L=50; InstallationDate: n/a; SerialNumber: n/a; TagNumber: n/a; Type: 443510(2021): 443510 Shut-off connector, DN10, L=50; Type Id: 443510(2021): 443510 Shut-off connector, DN10, L=50; WarrantyStartDate: n/a
Phasing - Phase Created: Phase 1
